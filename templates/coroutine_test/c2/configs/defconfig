## templates/filesystem_test/c2/configs/defconfig
```kconfig
CONFIG_COMPONENT_SPI_SOFTWARE=y
CONFIG_COMPONENT_SFUD=y
CONFIG_COMPONENT_FLASH_FS=y
```
